FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://camera-v4l2.scc file://camera-v4l2.cfg"
